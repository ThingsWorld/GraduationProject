# Keil uVision project WareHouse.uvprojx, settings and files
target WareHouse (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WareHouse +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\DEVICES\DHT11;..\SYSTEM;..\DEVICES\LED;..\DEVICES\UART;..\DEVICES\ADC3;..\DEVICES\LIGHT_SENSOR;..\UCOSII\CFG;..\UCOSII\CORE;..\UCOSII\CPU;..\UCOSII\LIB;..\UCOSII\PORT;..\DEVICES\BEEP;..\DEVICES\WKUP;..\DEVICES\LCD;..\DEVICES\LCD;..\ST_CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group DEVICES
    ../DEVICES/DHT11/: dht11.c
    ../DEVICES/LED/: led.c
    ../DEVICES/UART/: uart.c
    ../DEVICES/ADC3/: adc3.c
    ../DEVICES/LIGHT_SENSOR/: light_sensor.c
    ../DEVICES/BEEP/: beep.c
    ../DEVICES/WKUP/: wkup.c
    ../DEVICES/LCD/: lcd.c
  group UCOSII_APP
    ../UCOSII/APP/: app_hooks.c
  group UCOSII_LIB
    ../UCOSII/LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group UCOSII_CPU
    ../UCOSII/CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ST_CORE
    ../ST_CORE/: stm32f4xx_exti.c
software components: CMSIS:CORE 4.3.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:RTC 1.4.2, Device:STM32Cube HAL:SRAM 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:Startup 2.4.2
